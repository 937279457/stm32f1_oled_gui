# Keil uVision project C8T6.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: C8T6 +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Startup;.\Library;.\User;.\Hardware;.\Graphics;.\mpu6050
  memory RVCT4: ROM 0x8000000 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c main.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/: delay.c delay.h softwaretimer.c softwaretimer.h key.c key.h myexti.c myexti.h timer.c timer.h io.c io.h myi2c.c myi2c.h myspi.c myspi.h oled.c oled.h mydma.c mydma.h pwm.c pwm.h serial.c serial.h bkp.c bkp.h myrtc.c myrtc.h lowpower.c lowpower.h myflash.c myflash.h wdg.c wdg.h w25qxx.c w25qxx.h encoder.c encoder.h buzzer.c buzzer.h myadc.c myadc.h ic.c ic.h
  group Graphics
    ./Graphics/: font.c font.h graphics_mono.c graphics_mono.h gui.c gui.h guibase.c guibase.h guilist.c guilist.h guimenu.c guimenu.h image.h guiadc.c guiadc.h
  group mpu6050
    ./mpu6050/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h
